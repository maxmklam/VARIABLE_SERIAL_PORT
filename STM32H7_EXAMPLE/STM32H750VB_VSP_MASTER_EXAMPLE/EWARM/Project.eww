<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\STM32H750VB_VSP_MASTER_EXAMPLE.ewp</path>
    </project>
    <batchBuild />
</workspace>
