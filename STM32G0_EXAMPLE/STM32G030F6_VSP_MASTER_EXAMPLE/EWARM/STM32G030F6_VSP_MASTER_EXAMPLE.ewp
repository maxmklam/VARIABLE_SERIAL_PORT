# IAR project STM32G030F6_VSP_MASTER_EXAMPLE.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32G030F6 ST STM32G030F6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; HSE_VALUE=8000000; HSE_STARTUP_TIMEOUT=100; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; EXTERNAL_CLOCK_VALUE=12288000; HSI_VALUE=16000000; LSI_VALUE=32000; VDD_VALUE=3300; PREFETCH_ENABLE=1; INSTRUCTION_CACHE_ENABLE=1; DATA_CACHE_ENABLE=1; STM32G030xx
  ICCARM.CCIncludePath2: ../../Drivers/STM32G0xx_HAL_Driver/Inc; ../../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../../Drivers/CMSIS/Include; ..; ../Core/Inc; ../myCode_MCU; ../myCode_MCU/VSP_4_MCU; ../..; ../../myCode_STM32G0; ../../myCode_STM32G0/myLIB_4_STM32G0; ../../..; ../../../VSP; ../../../myLIB
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32G030F6_VSP_MASTER_EXAMPLE.bin
  ILINK.IlinkOutputFile: OUTPUT.out
  ILINK.IlinkIcfFile: stm32g030xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../: myCompileTime.h myDevice.h myTypedef.h
  group Core
    ../Core/Src/: crc.c dma.c gpio.c main.c spi.c stm32g0xx_it.c tim.c
  group DOC
    ./: iar_project_include_paths_and_linker_file.txt
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_crc.c stm32g0xx_ll_dma.c stm32g0xx_ll_exti.c stm32g0xx_ll_gpio.c stm32g0xx_ll_i2c.c stm32g0xx_ll_pwr.c stm32g0xx_ll_rcc.c stm32g0xx_ll_rtc.c stm32g0xx_ll_spi.c stm32g0xx_ll_tim.c stm32g0xx_ll_utils.c
  group EWARM
    ./: startup_stm32g030xx.s
  group myCode_MCU
    ../myCode_MCU/: myDMA_MCU.c myDMA_MCU.h mySPI_MCU.c mySPI_MCU.h myTIM_MCU.c myTIM_MCU.h
  group myCode_MCU/VSP_4_MCU
    ../myCode_MCU/VSP_4_MCU/: VSP_4_MCU.c VSP_4_MCU.h
  group myCode_STM32G0
    ../../myCode_STM32G0/: myCRC_STM32G0.c myCRC_STM32G0.h myDMA_STM32G0.c myDMA_STM32G0.h mySPI_STM32G0.c mySPI_STM32G0.h myTIM_STM32G0.c myTIM_STM32G0.h
  group myCode_STM32G0/myLIB_4_STM32G0
    ../../myCode_STM32G0/myLIB_4_STM32G0/: myTimebase_4_STM32G0.c myTimebase_4_STM32G0.h
  group myLIB
    ../../../myLIB/: myTimebase.c myTimebase.h
  group VSP
    ../../../VSP/: VSP.c VSP.h
