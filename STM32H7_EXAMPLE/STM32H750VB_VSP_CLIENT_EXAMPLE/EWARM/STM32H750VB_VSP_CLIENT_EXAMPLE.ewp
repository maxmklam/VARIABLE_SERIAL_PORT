# IAR project STM32H750VB_VSP_CLIENT_EXAMPLE.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32H750VB ST STM32H750VB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; HSE_VALUE=25000000; HSE_STARTUP_TIMEOUT=100; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; EXTERNAL_CLOCK_VALUE=12288000; HSI_VALUE=64000000; LSI_VALUE=32000; VDD_VALUE=3300; STM32H750xx
  ICCARM.CCIncludePath2: ../../Drivers/STM32H7xx_HAL_Driver/Inc; ../../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../../Drivers/CMSIS/Include; ..; ../Core/Inc; ../myCode_MCU; ../myCode_MCU/VSP_4_MCU; ../..; ../../myCode_STM32H7; ../../myCode_STM32H7/myLIB_4_STM32H7; ../../..; ../../../VSP; ../../../myLIB
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32H750VB_VSP_CLIENT_EXAMPLE.bin
  ILINK.IlinkOutputFile: OUTPUT.out
  ILINK.IlinkIcfFile: stm32h750xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../: myCompileTime.h myDevice.h myTypedef.h
  group Core
    ../Core/Src/: crc.c dma.c gpio.c main.c spi.c stm32h7xx_it.c tim.c
  group DOC
    ./: iar_project_include_paths_and_linker_file.txt
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_crc.c stm32h7xx_ll_dma.c stm32h7xx_ll_exti.c stm32h7xx_ll_gpio.c stm32h7xx_ll_pwr.c stm32h7xx_ll_rcc.c stm32h7xx_ll_spi.c stm32h7xx_ll_tim.c stm32h7xx_ll_utils.c
  group EWARM
    ./: startup_stm32h750xx.s
  group myCode_MCU
    ../myCode_MCU/: myDMA_MCU.c myDMA_MCU.h mySPI_MCU.c mySPI_MCU.h myTIM_MCU.c myTIM_MCU.h
  group myCode_MCU/VSP_4_MCU
    ../myCode_MCU/VSP_4_MCU/: VSP_4_MCU.c VSP_4_MCU.h
  group myCode_STM32H7
    ../../myCode_STM32H7/: myCRC_STM32H7.c myCRC_STM32H7.h myDMA_STM32H7.c myDMA_STM32H7.h mySPI_STM32H7.c mySPI_STM32H7.h myTIM_STM32H7.c myTIM_STM32H7.h
  group myCode_STM32H7/myLIB_4_STM32H7
    ../../myCode_STM32H7/myLIB_4_STM32H7/: myTimebase_4_STM32H7.c myTimebase_4_STM32H7.h
  group myLIB
    ../../../myLIB/: myTimebase.c myTimebase.h
  group VSP
    ../../../VSP/: VSP.c VSP.h
