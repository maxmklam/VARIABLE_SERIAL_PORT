<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\STM32G030F6_VSP_CLIENT_EXAMPLE.ewp</path>
    </project>
    <batchBuild />
</workspace>
